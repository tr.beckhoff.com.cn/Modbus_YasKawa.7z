PROGRAM MAIN
VAR

END_VAR

ModbusMaster();

END_PROGRAM
