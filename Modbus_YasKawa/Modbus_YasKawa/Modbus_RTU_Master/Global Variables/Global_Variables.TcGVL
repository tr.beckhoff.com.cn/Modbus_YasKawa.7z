{attribute 'Tc2GvlVarNames'}
VAR_GLOBAL

END_VAR
